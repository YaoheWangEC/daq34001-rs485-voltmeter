# Keil uVision project voltmeter-f421g8u7.uvprojx, settings and files
target voltmeter-f421g8u7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F421G8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.9
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: voltmeter-f421g8u7 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421G8U7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\middlewares\i2c_application_library;.\voltmeter;.\voltmeter\command;.\voltmeter\bsp;.\voltmeter\bsp\lcd
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group application
    ./voltmeter/: global_vars.c user.c
  group user
    ../src/: at32f421_int.c at32f421_wk_config.c main.c wk_system.c wk_i2c.c wk_spi.c wk_usart.c wk_gpio.c wk_dma.c
  group firmware
    ../../libraries/drivers/src/: at32f421_crm.c at32f421_gpio.c at32f421_i2c.c at32f421_usart.c at32f421_pwc.c at32f421_spi.c at32f421_dma.c at32f421_debug.c at32f421_flash.c at32f421_misc.c at32f421_scfg.c
  group cmsis
    ../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ./: startup_at32f421.s
  group command
    ./voltmeter/command/: command_io.c command_fifo.c command_handler.c command_parser.c command_table.c
  group bsp
    ../../middlewares/i2c_application_library/: i2c_application.c
    ./voltmeter/bsp/: bsp.c eeprom.c sgm58031.c
  group bsp/lcd
    ./voltmeter/bsp/lcd/: colorlut.c lcd.c lcd_io.c lcdfont.c
